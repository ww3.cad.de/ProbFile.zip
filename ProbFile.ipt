# Autodesk Inventor part: ProbFile
## iProperties
Created: 2010-03
Part Number: ProbFile
Document SubType Name: Modeling
Designer: damm
Author: damm
## Feature names
1. Extrusion1
2. Extrusion2
